# Disabled in favor of systemd-networkd
SYSTEMD_AUTO_ENABLE:${PN} = "disable"
